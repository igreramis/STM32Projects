<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\G0B1_PWM_Practice.ewp</path>
  </project>
  <batchBuild />
</workspace>
